File: quadcopter-control-board.sch (EAGLE design)
At the start: 34 parts, among them Q1 12MHz, X1 USB-SMD-NS

Commit message: Adding v3.
Other:
- moved on the sheet: R6, R8, R9
